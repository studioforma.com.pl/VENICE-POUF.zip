Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Venice - Pouf - v4.ifc
Time: 2023-11-10T15:41:47
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (11)
Name
 | ddd_9 - ObjectType: SketchupGroup
 | ddd_8 - ObjectType: SketchupGroup
 | ddd_7 - ObjectType: SketchupGroup
 | ddd_6 - ObjectType: SketchupGroup
 | ddd_5 - ObjectType: SketchupGroup
 | ddd_0 - ObjectType: SketchupGroup
 | ddd_4 - ObjectType: SketchupGroup
 | ddd_3 - ObjectType: SketchupGroup
 | ddd_2 - ObjectType: SketchupGroup
 | ddd_1 - ObjectType: SketchupGroup
 | ddd_10 - ObjectType: SketchupGroup
